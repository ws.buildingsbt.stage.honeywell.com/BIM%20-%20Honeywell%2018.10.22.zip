Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2022-10-18T16:27:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 18 16:27:53 2022 * Host: JRLAP22DELL * Database: C:\Users\JAMESR~1\AppData\Local\Temp\{5B8E367C-0A63-4751-9318-DECB25F10279}\ifc * Database version: 5507 * Database creation date: Tue Oct 18 16:27:50 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 18 16:27:50 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 18 16:27:50 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcBuildingElementProxy: CS2747 - LogicPlus (Graphite), MK-Electric_ElectricalFixtures_DoubleSocket_Switched:CS2747 - LogicPlus (Graphite):305173
In: Level 0
Type - Material: Graphite
Pset_BuildingElementProxyCommon - Reference: CS2747 - LogicPlus (Graphite)
Pset_ManufacturerTypeInformation - Manufacturer: MK Electric
