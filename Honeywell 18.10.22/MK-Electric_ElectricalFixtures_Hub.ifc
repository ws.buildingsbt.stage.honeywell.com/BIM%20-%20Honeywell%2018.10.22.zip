Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2022-10-18T16:28:47
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 18 16:28:47 2022 * Host: JRLAP22DELL * Database: C:\Users\JAMESR~1\AppData\Local\Temp\{DC51612E-FFC1-496B-9B75-D3CC20058FC9}\ifc * Database version: 5507 * Database creation date: Tue Oct 18 16:28:45 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 18 16:28:45 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 18 16:28:45 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcBuildingElementProxy: CSHUB1, MK-Electric_ElectricalFixtures_Hub:CSHUB1:306331
In: Level 0
Type - Material: Plastic White
Pset_BuildingElementProxyCommon - Reference: CSHUB1
Pset_ManufacturerTypeInformation - Manufacturer: "MK Electric"
